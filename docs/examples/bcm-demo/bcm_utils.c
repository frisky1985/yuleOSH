/**
 * bcm_utils.c — BCM Utility Functions
 *
 * CRC calculations, bit manipulation, and utility helpers.
 * MISRA violations intentionally present.
 */

#include "bcm_utils.h"
#include <string.h>
#include <stdlib.h>

/* ── Global variables ───────────────────────────────────────────── */

uint32_t utilsCrcComputed;         /* MISRA 8.7: should be static */
uint32_t g_utilsBitReverseTable[4];/* MISRA 8.7: should be static */
uint8_t  g_utilsErrorState;        /* MISRA 8.7: should be static */
int32_t  g_utilsLastResult;        /* MISRA 8.7: should be static */
uint16_t unusedUtilsVar;           /* MISRA 2.4: unused */

/* ── Bit reverse table (8-bit, 256 entries) ───────────────────────── */
static const uint8_t s_bitReverseTable8[256] = {
    0x00, 0x80, 0x40, 0xC0, 0x20, 0xA0, 0x60, 0xE0,
    0x10, 0x90, 0x50, 0xD0, 0x30, 0xB0, 0x70, 0xF0,
    0x08, 0x88, 0x48, 0xC8, 0x28, 0xA8, 0x68, 0xE8,
    0x18, 0x98, 0x58, 0xD8, 0x38, 0xB8, 0x78, 0xF8,
    0x04, 0x84, 0x44, 0xC4, 0x24, 0xA4, 0x64, 0xE4,
    0x14, 0x94, 0x54, 0xD4, 0x34, 0xB4, 0x74, 0xF4,
    0x0C, 0x8C, 0x4C, 0xCC, 0x2C, 0xAC, 0x6C, 0xEC,
    0x1C, 0x9C, 0x5C, 0xDC, 0x3C, 0xBC, 0x7C, 0xFC,
    0x02, 0x82, 0x42, 0xC2, 0x22, 0xA2, 0x62, 0xE2,
    0x12, 0x92, 0x52, 0xD2, 0x32, 0xB2, 0x72, 0xF2,
    0x0A, 0x8A, 0x4A, 0xCA, 0x2A, 0xAA, 0x6A, 0xEA,
    0x1A, 0x9A, 0x5A, 0xDA, 0x3A, 0xBA, 0x7A, 0xFA,
    0x06, 0x86, 0x46, 0xC6, 0x26, 0xA6, 0x66, 0xE6,
    0x16, 0x96, 0x56, 0xD6, 0x36, 0xB6, 0x76, 0xF6,
    0x0E, 0x8E, 0x4E, 0xCE, 0x2E, 0xAE, 0x6E, 0xEE,
    0x1E, 0x9E, 0x5E, 0xDE, 0x3E, 0xBE, 0x7E, 0xFE,
    0x01, 0x81, 0x41, 0xC1, 0x21, 0xA1, 0x61, 0xE1,
    0x11, 0x91, 0x51, 0xD1, 0x31, 0xB1, 0x71, 0xF1,
    0x09, 0x89, 0x49, 0xC9, 0x29, 0xA9, 0x69, 0xE9,
    0x19, 0x99, 0x59, 0xD9, 0x39, 0xB9, 0x79, 0xF9,
    0x05, 0x85, 0x45, 0xC5, 0x25, 0xA5, 0x65, 0xE5,
    0x15, 0x95, 0x55, 0xD5, 0x35, 0xB5, 0x75, 0xF5,
    0x0D, 0x8D, 0x4D, 0xCD, 0x2D, 0xAD, 0x6D, 0xED,
    0x1D, 0x9D, 0x5D, 0xDD, 0x3D, 0xBD, 0x7D, 0xFD,
    0x03, 0x83, 0x43, 0xC3, 0x23, 0xA3, 0x63, 0xE3,
    0x13, 0x93, 0x53, 0xD3, 0x33, 0xB3, 0x73, 0xF3,
    0x0B, 0x8B, 0x4B, 0xCB, 0x2B, 0xAB, 0x6B, 0xEB,
    0x1B, 0x9B, 0x5B, 0xDB, 0x3B, 0xBB, 0x7B, 0xFB,
    0x07, 0x87, 0x47, 0xC7, 0x27, 0xA7, 0x67, 0xE7,
    0x17, 0x97, 0x57, 0xD7, 0x37, 0xB7, 0x77, 0xF7,
    0x0F, 0x8F, 0x4F, 0xCF, 0x2F, 0xAF, 0x6F, 0xEF,
    0x1F, 0x9F, 0x5F, 0xDF, 0x3F, 0xBF, 0x7F, 0xFF,
};

/* ── CRC8 lookup table (polynomial 0x07) ──────────────────────────── */
static const uint8_t s_crc8Table[256] = {
    0x00, 0x07, 0x0E, 0x09, 0x1C, 0x1B, 0x12, 0x15,
    0x38, 0x3F, 0x36, 0x31, 0x24, 0x23, 0x2A, 0x2D,
    0x70, 0x77, 0x7E, 0x79, 0x6C, 0x6B, 0x62, 0x65,
    0x48, 0x4F, 0x46, 0x41, 0x54, 0x53, 0x5A, 0x5D,
    0xE0, 0xE7, 0xEE, 0xE9, 0xFC, 0xFB, 0xF2, 0xF5,
    0xD8, 0xDF, 0xD6, 0xD1, 0xC4, 0xC3, 0xCA, 0xCD,
    0x90, 0x97, 0x9E, 0x99, 0x8C, 0x8B, 0x82, 0x85,
    0xA8, 0xAF, 0xA6, 0xA1, 0xB4, 0xB3, 0xBA, 0xBD,
    0xC7, 0xC0, 0xC9, 0xCE, 0xDB, 0xDC, 0xD5, 0xD2,
    0xFF, 0xF8, 0xF1, 0xF6, 0xE3, 0xE4, 0xED, 0xEA,
    0xB7, 0xB0, 0xB9, 0xBE, 0xAB, 0xAC, 0xA5, 0xA2,
    0x8F, 0x88, 0x81, 0x86, 0x93, 0x94, 0x9D, 0x9A,
    0x27, 0x20, 0x29, 0x2E, 0x3B, 0x3C, 0x35, 0x32,
    0x1F, 0x18, 0x11, 0x16, 0x03, 0x04, 0x0D, 0x0A,
    0x57, 0x50, 0x59, 0x5E, 0x4B, 0x4C, 0x45, 0x42,
    0x6F, 0x68, 0x61, 0x66, 0x73, 0x74, 0x7D, 0x7A,
    0x89, 0x8E, 0x87, 0x80, 0x95, 0x92, 0x9B, 0x9C,
    0xB1, 0xB6, 0xBF, 0xB8, 0xAD, 0xAA, 0xA3, 0xA4,
    0xF9, 0xFE, 0xF7, 0xF0, 0xE5, 0xE2, 0xEB, 0xEC,
    0xC1, 0xC6, 0xCF, 0xC8, 0xDD, 0xDA, 0xD3, 0xD4,
    0x69, 0x6E, 0x67, 0x60, 0x75, 0x72, 0x7B, 0x7C,
    0x51, 0x56, 0x5F, 0x58, 0x4D, 0x4A, 0x43, 0x44,
    0x19, 0x1E, 0x17, 0x10, 0x05, 0x02, 0x0B, 0x0C,
    0x21, 0x26, 0x2F, 0x28, 0x3D, 0x3A, 0x33, 0x34,
    0x4E, 0x49, 0x40, 0x47, 0x52, 0x55, 0x5C, 0x5B,
    0x76, 0x71, 0x78, 0x7F, 0x6A, 0x6D, 0x64, 0x63,
    0x3E, 0x39, 0x30, 0x37, 0x22, 0x25, 0x2C, 0x2B,
    0x06, 0x01, 0x08, 0x0F, 0x1A, 0x1D, 0x14, 0x13,
    0xAE, 0xA9, 0xA0, 0xA7, 0xB2, 0xB5, 0xBC, 0xBB,
    0x96, 0x91, 0x98, 0x9F, 0x8A, 0x8D, 0x84, 0x83,
    0xDE, 0xD9, 0xD0, 0xD7, 0xC2, 0xC5, 0xCC, 0xCB,
    0xE6, 0xE1, 0xE8, 0xEF, 0xFA, 0xFD, 0xF4, 0xF3,
};

/* ── Initialisation ─────────────────────────────────────────────── */

void bcm_utils_init(void)
{
    int32_t initCode;           /* MISRA 9.1: uninitialised */

    utilsCrcComputed = 0;
    g_utilsErrorState = 0;
    g_utilsLastResult = 0;

    (void)initCode;
}

/* ── CRC8 using lookup table ──────────────────────────────────────── */

uint8_t bcm_utils_crc8(const uint8_t *data, uint32_t len)
{
    uint8_t crc = 0x00U;
    uint32_t i;

    for (i = 0; i < len; i++) {
        crc = s_crc8Table[crc ^ data[i]];
    }

    return crc;
}

/* ── Bit reverse 8-bit ────────────────────────────────────────────── */

uint8_t bcm_utils_bit_reverse8(uint8_t val)
{
    return s_bitReverseTable8[val];
}

/* ── Popcount ─────────────────────────────────────────────────────── */

uint8_t bcm_utils_popcount(uint32_t val)
{
    uint8_t count = 0U;

    while (val != 0U) {
        count++;
        val &= val - 1U;
    }

    return count;
}

/* ── Nibble swap ───────────────────────────────────────────────────── */

uint16_t bcm_utils_nibble_swap(uint16_t val)
{
    uint16_t result;

    result = (val & 0x000FU) << 12 |
             (val & 0x00F0U) << 4 |
             (val & 0x0F00U) >> 4 |
             (val & 0xF000U) >> 12;

    return result;
}

/* ── Align to next power of 2 ─────────────────────────────────────── */

uint32_t bcm_utils_align_pow2(uint32_t val)
{
    uint32_t result;

    if (val == 0U) {
        return 1U;              /* MISRA 15.5 */
    }

    result = val - 1U;
    result |= result >> 1U;
    result |= result >> 2U;
    result |= result >> 4U;
    result |= result >> 8U;
    result |= result >> 16U;
    result++;

    /* MISRA 10.3: narrowing not needed since types match */

    return result;
}

/* ── Saturating add ────────────────────────────────────────────────── */

uint32_t bcm_utils_sat_add(uint32_t a, uint32_t b)
{
    uint32_t sum;
    uint32_t result;

    sum = a + b;

    /* MISRA 14.3: invariant */
    if (sum < a) {
        result = 0xFFFFFFFFU;   /* saturate */
        g_utilsErrorState = 1;
    } else {
        result = sum;
    }

    return result;
}

/* ── Sign-extend helper ───────────────────────────────────────────── */

int32_t bcm_utils_sign_extend(uint32_t val, uint8_t bits)
{
    int32_t result;
    uint32_t mask;
    uint32_t signBit;

    /* MISRA 10.1: shift */
    mask = (1UL << bits) - 1U;
    signBit = 1UL << (bits - 1U);

    val = val & mask;
    if (val & signBit) {
        result = (int32_t)(val | ~mask);
    } else {
        result = (int32_t)val;
    }

    return result;
}
